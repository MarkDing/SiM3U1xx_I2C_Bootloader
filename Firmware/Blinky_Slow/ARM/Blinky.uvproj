# Keil uVision project Blinky.uvproj, settings and files
target Blinky (ARM-ADS)
  device: SiM3U167 Silicon Laboratories, Inc.
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: Blinky_Slow +hex
  c flags: Optim=1
  c define: NDEBUG
  c misc: --c99 --gnu
  c include: ..\src\.;..\src\generated;C:\SiLabs\32bit\si32-1.1.1\si32Hal\sim3u1xx;C:\SiLabs\32bit\si32-1.1.1\si32Hal\CPU;C:\SiLabs\32bit\si32-1.1.1\si32Hal\SI32_Modules
  asm include: ..\src\.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\src\linker_sim3u1xx_arm.sct
  group CPU
    C:/SiLabs/32bit/si32-1.1.1/si32Hal/CPU/: retarget_arm.c
  group SI32_Modules
    C:/SiLabs/32bit/si32-1.1.1/si32Hal/SI32_Modules/: SI32_AES_A_Type.c SI32_CAPSENSE_A_Type.c SI32_CMP_A_Type.c SI32_CRC_A_Type.c SI32_DMACTRL_A_Type.c SI32_EMIFIF_A_Type.c SI32_EMIF_A_Type.c SI32_EPCACH_A_Type.c SI32_EPCA_A_Type.c SI32_EXTOSC_A_Type.c SI32_EXTVREG_A_Type.c SI32_FLASHCTRL_A_Type.c SI32_I2C_A_Type.c SI32_I2S_A_Type.c SI32_IDAC_A_Type.c SI32_IVC_A_Type.c SI32_LPTIMER_A_Type.c SI32_PCACH_A_Type.c SI32_PCA_A_Type.c SI32_PLL_A_Type.c SI32_RTC_A_Type.c SI32_SARADC_A_Type.c SI32_SPI_A_Type.c SI32_SSG_A_Type.c SI32_TIMER_A_Type.c SI32_UART_A_Type.c SI32_USART_A_Type.c SI32_USBEP_A_Type.c SI32_USB_A_Type.c SI32_VMON_A_Type.c SI32_VREF_A_Type.c SI32_VREG_A_Type.c SI32_WDTIMER_A_Type.c
  group sim3u1xx
    C:/SiLabs/32bit/si32-1.1.1/si32Hal/sim3u1xx/: system_sim3u1xx.c startup_sim3u1xx_arm.s SI32_DMAXBAR_A_Type.c SI32_CLKCTRL_A_Type.c SI32_DEVICEID_A_Type.c SI32_LDO_A_Type.c SI32_LOCK_A_Type.c SI32_PBCFG_A_Type.c SI32_PBHD_A_Type.c SI32_PBSTD_A_Type.c SI32_PMU_A_Type.c SI32_RSTSRC_A_Type.c SI32_SCONFIG_A_Type.c
  group Blinky
    ../src/: main.c myCpu.c myPB.c myRtc0.c
  group generated
    ../src/generated/: gCpu.c gModes.c gPB.c gRtc0.c
  group Readme
    ../src/: Blinky_Readme.txt
