# Keil uVision project SiMxxxxx_Bootloader.uvproj, settings and files
target PROTOCOL (ARM-ADS)
  device: SiM3U167 Silicon Laboratories, Inc.
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: simxxxxx_protocol_bootloader +hex
  c flags: Optim=4
  c define: NDEBUG,  MCU_FAMILY=SiMXXX, COMM_PROTOCOL=PROTOCOL
  c misc: --c99 --gnu
  c include: .\framework;.\src\framework;C:\SiLabs\32bit\si32-1.1.1\si32Hal\CPU;C:\SiLabs\32bit\si32-1.1.1\si32Hal\SI32_Modules;C:\SiLabs\32bit\si32-1.1.1\si32Hal\sim3u1xx
  asm misc: --cpreproc --cpreproc_opts='-DMCU_FAMILY=SiMXXX'  --cpreproc_opts='-DCOMM_PROTOCOL=PROTOCOL'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: C:\SiLabs\32bit\si32-1.1.1\si32Hal\sim3l1xx\linker_sim3l1xx_arm.sct
  group Startup and Main
    ./src/framework/: retarget_arm.c main.c startup_simxxxxx_arm.s
  group Framework Configuration
    ./src/framework/: userconfig.h factoryconfig.h
  group Framework Header Files
    ./src/framework/: global.h const.h types.h dfu.h filemgr.h comm.h flctl.h device.h
  group Framework Source Files
    ./src/framework/: dfu.c filemgr.c
  group Device Specific Files
    ./src/device_specific_simxxxxx/: device_simxxxxx.h device_userconfig_simxxxxx.h device_simxxxxx.c flctl_simxxxxx.h flctl_simxxxxx.c
  group Comm Specific Files (PROTOCOL)
    ./src/comm_specific_protocol_simxxxxx/: comm_protocol_simxxxxx.c comm_protocol_simxxxxx.h
