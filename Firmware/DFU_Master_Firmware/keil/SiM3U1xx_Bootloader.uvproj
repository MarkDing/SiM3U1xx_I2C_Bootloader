# Keil uVision project SiM3U1xx_Bootloader.uvproj, settings and files
target UART (ARM-ADS)
  device: SiM3U167 Silicon Laboratories, Inc.
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: sim3u1xx_uart_bootloader +hex
  c flags: Optim=4
  c define: NDEBUG,  MCU_FAMILY=SiM3U1, COMM_PROTOCOL=UART
  c misc: --c99 --gnu
  c include: ..\src\framework;C:\SiLabs\32bit\si32-1.1.1\si32Hal\CPU;C:\SiLabs\32bit\si32-1.1.1\si32Hal\SI32_Modules;C:\SiLabs\32bit\si32-1.1.1\si32Hal\sim3u1xx
  asm misc: --cpreproc --cpreproc_opts='-DMCU_FAMILY=SiM3U1'  --cpreproc_opts='-DCOMM_PROTOCOL=UART'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: C:\SiLabs\32bit\si32-1.1.1\si32Hal\sim3l1xx\linker_sim3l1xx_arm.sct
  group Startup and Main
    ../src/framework/: main.c retarget_arm.c startup_simxxxxx_arm.s
  group Framework Configuration
    ../src/framework/: factoryconfig.h userconfig.h
  group Framework Header Files
    ../src/framework/: global.h const.h types.h dfu.h filemgr.h comm.h flctl.h device.h
  group Framework Source Files
    ../src/framework/: dfu.c filemgr.c
  group Device Specific Files
    ../src/device_specific_sim3u1xx/: device_sim3u1xx.c flctl_sim3u1xx.c device_sim3u1xx.h device_userconfig_sim3u1xx.h flctl_sim3u1xx.h flctl_userconfig_sim3u1xx.h
  group Comm Specific Files (UART)
    ../src/comm_specific_uart_sim3u1xx/: comm_uart_sim3u1xx.c comm_uart_sim3u1xx.h
  group Comm Specific Files (USB)
    ../src/comm_specific_usb_sim3u1xx/: comm_usb_sim3u1xx.c USB0_ControlRequests.c USB0_Descriptor.c USB0_ISR.c USB0_StandardRequests.c comm_usb_sim3u1xx.h
target USB (ARM-ADS)
  device: SiM3U167 Silicon Laboratories, Inc.
  cpu: as above
  output: sim3u1xx_usb_bootloader +hex
  c flags: Optim=4
  c define: NDEBUG,  MCU_FAMILY=SiM3U1, COMM_PROTOCOL=USB
  c misc: --c99 --gnu
  c include: .\framework;.\src\framework;C:\SiLabs\32bit\si32-1.1.1\si32Hal\CPU;C:\SiLabs\32bit\si32-1.1.1\si32Hal\SI32_Modules;C:\SiLabs\32bit\si32-1.1.1\si32Hal\sim3u1xx
  asm misc: --cpreproc --cpreproc_opts='-DMCU_FAMILY=SiM3U1'  --cpreproc_opts='-DCOMM_PROTOCOL=USB'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: as above
